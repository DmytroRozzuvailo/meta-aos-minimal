FILESEXTRAPATHS_prepend := "${THISDIR}/initscripts:"

