FILESEXTRAPATHS_prepend := "${THISDIR}/initramfs-framework:"
SRC_URI += " file://finish"
