# change source repo on internal one with proper patches for current board
SRC_URI = "git://git@gitpct.epam.com/Dmytro_Rozzuvailo/uboot-imx.git;protocol=ssh;branch=rm-n8mmi_smc-5.4.47_2.2.0"
SRCREV="${AUTOREV}"
SRCREV_machine="${AUTOREV}"
